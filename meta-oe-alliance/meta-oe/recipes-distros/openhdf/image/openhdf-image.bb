SUMMARY = "Build openHDF Image with Feed"

DEPENDS += "openhdf-feeds"

require openhdf-image.inc
